.title KiCad schematic
D3 __D3
D2 __D2
D1 __D1
R22 Net-_IC3-VRB_ GND 1k
R21 +3.3V Net-_IC3-VRB_ 10k
C17 Net-_IC3-VRB_ GND 1u
C11 Net-_IC3-VRM_ GND 0.1u
IC2 __IC2
R16 Net-_IC2-_DIS_ +5V PLACEHOLDER
C10 Net-_D1-K_ Net-_IC2-OUT_ PLACEHOLDER
R15 Net-_D1-K_ Net-_IC2-OUT_ PLACEHOLDER
C16 Net-_IC3-VRT_ GND 1u
C12 GND AVDD33 0.1u
R17 +3.3V Net-_IC3-VRT_ 1.1k
R18 Net-_IC3-VRT_ GND 1.5k
C13 AVDD33 GND 10u
C15 GND +3.3V 0.1u
C14 +3.3V GND 10u
IC3 __IC3
U1 __U1
R23 Net-_U1-RXD_3/PHY_AD4_ GND 2.2k
R20 GND Net-_U1-RXD_2/PHY_AD3_ 2.2k
R19 GND Net-_U1-TXD_3/SNI_MODE_ 2.2k
R25 +3.3V Net-_U1-RX_ER/MDIX_EN_ 2.2k
R24 Net-_U1-COL/PHY_AD0_ +3.3V 2.2k
R28 Net-_U1-MDIO_ +3.3V 2.2k
R27 +3.3V Net-_U1-_RESET_ 2.2k
R26 Net-_U1-PWR_DOWN/INT_ GND 2.2k
C9 Net-_U1-PFBIN1_ GND 0.1u
R12 GND Net-_U1-AN_EN/LED_ACT/COL_ 2.2k
C6 Net-_U1-PFBIN1_ GND 0.1u
C7 Net-_U1-PFBIN1_ GND 0.1u
C8 Net-_U1-PFBIN1_ GND 10u
R14 +3.3V Net-_U1-AN0/LED_LINK_ 2.2k
R13 +3.3V Net-_U1-AN1/LED_SPEED_ 2.2k
R6 +3.3V Net-_TR1-RD+_ 49.9
C4 +3.3V GND 0.1u
C5 +3.3V GND 0.1u
C1 Net-_C1-Pad1_ GNDPWR 1000pF, 2kV
TR1 __TR1
R4 Net-_TR1-C_TX_ Net-_C1-Pad1_ 75
R3 Net-_TR1-C_RX_ Net-_C1-Pad1_ 75
R2 Net-_J1-Pad7_ Net-_C1-Pad1_ 75
R1 Net-_J1-Pad4_ Net-_C1-Pad1_ 75
J1 __J1
R5 Net-_TR1-RD-_ +3.3V 49.9
R11 GND Net-_U1-RBIAS_ 4.87k 1%
R9 AVDD33 Net-_R9-Pad2_ 2.2k
R10 AVDD33 Net-_R10-Pad2_ 2.2k
R7 Net-_TR1-TD-_ +3.3V 49.9
R8 +3.3V Net-_TR1-TD+_ 49.9
C3 +3.3V GND 0.1u
C2 +3.3V GND 0.1u
IC1 __IC1
X1 __X1
R29 Net-_IC1-PB4C_ Net-_Q1-G_ 100
LD1 Net-_LD1-A_ Net-_LD1-K_ OPV300
Q1 __Q1
R30 Net-_LD1-A_ +3.3V 50
.end
